# Keil uVision project iDProx.uvprojx, settings and files
target iDProx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: iDProx +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output=".\deploy\@L.bin" "!L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f0xx_it.c iwdg.c gpio.c main.c tim.c i2c.c stm32f0xx_hal_msp.c SerialOut.h SerialOut.c helper.h RF_common.h helper.c delay.h delay.c ABATK2.c ABATK2.h Wiegand.h Wiegand.c Output.c Output.h RF_ASK.h RF_ASK.c RC522_ErrCode.h RC522_Mifare.h RC522_MifareCmd.c RC522_OpCtrl.h RC522_Reg.h RC522_RegCtrl.c RC522_RegCtrl.h RF_Mifare.c RF_Mifare.h RF_Mifare_Util.c RF_Mifare_Util.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_i2c.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
software components: CMSIS:CORE 4.1.0
